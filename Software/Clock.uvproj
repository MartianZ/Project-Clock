# Keil uVision project Clock.uvproj, settings and files
target Target (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: STARTUP.A51 main.c STC_NEW_8051.h delay.c EEPROM.h
